*** SPICE deck for cell flipFlop{ic} from library sequentialLogic
*** Created on Mon Feb 15, 2016 16:57:30
*** Last revised on Mon Feb 15, 2016 18:17:29
*** Written on Tue Feb 16, 2016 13:26:00 by Electric VLSI Design System, version 9.06
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
* Model cards are described in this file:
.include /home/josh/Dropbox/OSU_VLSI/Spice/basics.spi

*** TOP LEVEL CELL: flipFlop{ic}
